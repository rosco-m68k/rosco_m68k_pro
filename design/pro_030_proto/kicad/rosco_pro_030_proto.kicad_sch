File: design/pro_030_proto/kicad/rosco_pro_030_proto.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Delete IDE
Other:
- removed sheet ATA-IDE
